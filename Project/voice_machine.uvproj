# Keil uVision project voice_machine.uvproj, settings and files
target voice_machine (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: voice_machine
  c flags: Optim=1
  c include: ..\User\LD3320;..\Drivers\BSP\STM32F4-Discovery;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\BSP\STM32F4-Discovery
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f40_41xxx.s
  group driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c
    ../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c
  group user
    ../User/: main.c
    ../User/LD3320/: LD3320.c Reg_RW.c
